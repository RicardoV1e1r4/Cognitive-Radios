options:
  parameters:
    author: Ricardo Alexandre
    generate_options: qt_gui
    id: DSBC_SC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: 240e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_audio
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '5'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_audio
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_32
    file: D:\Documentos\Faculdade\IC_Radios_Cognitivos\Sinal_e_Audio_do_GNURadio\AM_Signal
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '5'
    type: fff
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_audio
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: Modulatad Signal
    label2: Mesage
    nconnections: '2'
    size: '1024'
    srate: samp_rate_audio
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', blocks_repeat_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
