options:
  parameters:
    author: Ricardo Alexandre
    generate_options: qt_gui
    id: demodulation_DSSC_SC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Gain_demodulation
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: cutoff_frequency
  id: variable_qtgui_range
  parameters:
    start: '50'
    step: '50'
    stop: '25000'
    value: '1000'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_transition_width
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '50'
    stop: '2000'
    value: '1'
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documentos\Faculdade\IC_Radios_Cognitivos\Sinal_e_Audio_do_GNURadio\AM_Signal
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_frequency
    decim: '1'
    gain: Gain_demodulation
    samp_rate: samp_rate
    type: fir_filter_fff
    width: variable_transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Audio source
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}

connections:
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_1_0, '0', audio_sink_0, '0']
- [blocks_throttle2_1_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_throttle2_1_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_1_0, '0']
- [low_pass_filter_0, '0', blocks_throttle2_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
